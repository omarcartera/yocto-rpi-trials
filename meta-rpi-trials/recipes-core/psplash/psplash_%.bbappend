FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SPLASH_IMAGES:rpi = "file://psplash-rpi-trials-img.png;outsuffix=raspberrypi"
